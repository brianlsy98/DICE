* Current Mirror
* DC simulation

* Netlist

.include (MOS_SPEC)

MP0 Voutn Vclk  VDD VDD pmos W=(MP0W) L=(MP0L)
MP1 Voutn Voutp VDD VDD pmos W=(MP1W) L=(MP1L)
MP2 Voutp Voutn VDD VDD pmos W=(MP2W) L=(MP2L)
MP3 Voutp Vclk  VDD VDD pmos W=(MP3W) L=(MP3L)

MN0 Voutn  Voutp VMN0_S VSS nmos W=(MN0W) L=(MN0L)
MN1 Voutp  Voutn VMN1_S VSS nmos W=(MN1W) L=(MN1L)
MN2 VMN0_S Vinp  VMN4_D VSS nmos W=(MN2W) L=(MN2L)
MN3 VMN1_S Vinn  VMN4_D VSS nmos W=(MN3W) L=(MN3L)
MN4 VMN4_D Vclk  VSS    VSS nmos W=(MN3W) L=(MN3L)

* Simulation

.option TEMP=(TEMP)

Vpower  VDD   0  (VDD)
Vgnd    VSS   0  (VSS)
Vinput1 Vinp  0
Vinput2 Vinn  0  (VINN)
Vclock  Vclk  0  (VCLK)

.dc Vinput1 (Vin_min) (Vin_max) (Vin_step)

.control
    run
    wrdata (OUT_PATH) (OUT_DATA)
.endc

.END
